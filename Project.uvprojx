# Keil uVision project Project.uvprojx, settings and files
target NUCLEO_F401RE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c include: .\Low_Layer_Library;.\System_Files;.\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Files
    ./: stm32f4xx_it.c Time_Delays.c Clk_Config.c LCD_Display.c main.c
    ./System_Files/: startup_stm32f401xe.s system_stm32f4xx.c
    ./Low_Layer_Library/: stm32f4xx_ll_utils.c stm32f4xx_ll_adc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_i2c.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c
software components: CMSIS:CORE 5.0.0
